Commit message: added slam and nav2 capabilties

File: cafebot/urdf/cafebot.urdf (robot description, URDF)
Before this commit: robot cafebot, 13 links, 12 joints
Links:
- link body_column: mass 5.0 -> 3.0
